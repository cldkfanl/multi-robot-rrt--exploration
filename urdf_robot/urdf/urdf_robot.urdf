Commit message: urdf, sdf add

File: urdf_robot/urdf/urdf_robot.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 4 links, 3 joints
Joints:
- joint left_wheel_joint: type fixed -> continuous
- joint right_wheel_joint: type fixed -> continuous
